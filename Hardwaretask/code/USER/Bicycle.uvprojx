# Keil uVision project Bicycle.uvprojx, settings and files
target Bicycle (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: NewProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\OLED;..\HARDWARE\ADC;..\HARDWARE\ENCODER;..\HARDWARE\LED;..\HARDWARE\TIMER;..\SYSTEM\def;..\HARDWARE\MOTOR;..\HARDWARE\mpu6050;..\HARDWARE\mpu6050\eMPL;..\HARDWARE\exti;..\HARDWARE\pwm;..\HARDWARE\control;..\HARDWARE\beep;..\HARDWARE\wave;..\HARDWARE\key
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s
  group STM32F10x_FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/adc/: adc.c
    ../HARDWARE/encoder/: encoder.c
    ../HARDWARE/led/: led.c
    ../HARDWARE/motor/: motor.c
    ../HARDWARE/mpu6050/: mpu6050.c mpuiic.c
    ../HARDWARE/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../HARDWARE/control/: control.c
    ../HARDWARE/exti/: exti.c
    ../HARDWARE/pwm/: pwm.c
    ../HARDWARE/beep/: beep.c
    ../HARDWARE/wave/: wave.c
